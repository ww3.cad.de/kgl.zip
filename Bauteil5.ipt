# Autodesk Inventor part: ww3.cad.de:Bauteil5
## iProperties
Created: 2005-08
Document SubType Name: Modeling
