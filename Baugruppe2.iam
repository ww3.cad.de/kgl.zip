# Autodesk Inventor assembly: ww3.cad.de:Baugruppe2
## iProperties
Created: 2005-08
Document SubType Name: Assembly
