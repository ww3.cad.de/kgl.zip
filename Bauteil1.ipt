# Autodesk Inventor part: ww3.cad.de:Bauteil1
## iProperties
Created: 2005-08
Document SubType Name: Modeling
## Feature names
1. Drehung1 [Revolution]
